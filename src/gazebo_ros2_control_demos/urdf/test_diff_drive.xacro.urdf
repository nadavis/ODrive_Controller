Commit message: remove gazebo control and installl from root

File: src/gazebo_ros2_control_demos/urdf/test_diff_drive.xacro.urdf (robot description, URDF)
Before this commit: robot diff_drive, 5 links, 4 joints
Links:
- removed link base_link
Joints:
- removed joint chassis_joint
